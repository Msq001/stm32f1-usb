# Keil uVision project Project.uvprojx, settings and files
target STM3210E-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F10x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F10x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM3210E_EVAL;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_regs.c usb_int.c usb_core.c usb_mem.c usb_init.c
  group User
    ../src/: usb_prop.c usb_endp.c usb_desc.c stm32_it.c usb_istr.c usb_pwr.c hw_config.c main.c mass_mal.c memory.c usb_scsi.c usb_bot.c scsi_data.c
    ./: sd.c spi.c
  group STM32F10x/CMSIS
    ./: startup_stm32f10x_xl.s startup_stm32f10x_md.s startup_stm32f10x_hd.s
    ../src/: system_stm32f10x.c
  group Doc
    ../: readme.txt
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_sdio.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_flash.c
software components: CMSIS:CORE 4.3.0
